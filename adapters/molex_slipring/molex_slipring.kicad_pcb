# Repository ckh7488/balun_test

File README.md:

# LibreVNA balun Ethernet 측정

**2026-09-05 임피던스·주문 갱신:** [실제 화면과 옵션별 이유](docs/jlcpcb/README.md) · [계산기 결과 및 CAD 변경/검증](docs/jlcpcb/IMPEDANCE.md). 현재 W/G=0.234/0.216 mm, RF W=0.357 mm를 적용했다.

**Molex 배선 후속 개선:** [전후 그림·수치·설계 판단](docs/molex-routing/README.md). 신호 비아 0개를 유지하며 폭 0.234 mm 통일, A/B 길이 차이 0.79/0.99 mm를 적용했다.

산업용 100BASE-TX 케이블·커넥터·슬립링의 **정적 전송 품질을 먼저 평가**하기 위한 프로젝트다. 일반 RJ45 케이블과 사내 전용 핀맵의 케이블을 같은 플랫폼에서 측정한다.

**설계 검토를 시작한다면 [설계 의도·패치 범위·검토 인계](DESIGN_REVIEW_HANDOFF.md)를 먼저 읽는다.** 사용자 요구, 구현 선택 이유, 현재/이전 문서 구분, 검증 증거와 남은 질문을 정리했다. 현재는 배선된 CAD와 합성 검증 단계이며, O/S/L/T 표준 PCB·실물 RF 검증·새 구성의 제조 release는 아직 없다.

## 현재 기본 구성

양쪽에 `LibreVNA coax → SMA–balun–RJ45 PCB → 고정 RJ45 연결 → 교체형 커넥터 어댑터 → DUT`를 사용한다. 일반 RJ45 DUT는 어댑터 없이 연결한다. 최종 보정 기준면은 **어댑터 뒤의 DUT 접속면**이다. M12와 Molex 조합처럼 양끝 커넥터가 달라도 같은 원리를 사용한다.

1. LibreVNA에서 두 coax 끝의 **50 Ω full 2-port SOLT**를 수행하고 계속 활성화한다.
2. 지그와 어댑터를 고정하고 양쪽 DUT 접속면에서 O/S/L 각 3개와 자작 reciprocal thru 1개를 **측정·저장**한다.
3. Python `UnknownThru`가 이 **7개 표준 데이터**로 커넥터 끝 보정계수를 만든다.
4. 같은 SMA 보정 상태로 측정한 DUT `.s2p`에 저장된 계수를 적용한다. 결과는 **100 Ω balanced effective two-port** `.s2p`, CSV, 그래프다.

LibreVNA 화면은 SMA 기준으로 남는다. 자작 thru를 이상적인 0 ps thru로 등록해 LibreVNA에서 두 번째 SOLT를 켜는 절차가 아니다. 보정에 DUT 파일을 포함하지 않는다.

## 읽는 순서

| 문서/경로 | 내용 |
| --- | --- |
| [DESIGN_REVIEW_HANDOFF.md](DESIGN_REVIEW_HANDOFF.md) | 패치 목적과 변경 범위, 설계 판단 근거, 검토 우선순위·재현 방법 |
| [VNA_TEST_PLAN.md](VNA_TEST_PLAN.md) | 목적, 기준면, 표준 제작, 측정·검증 순서 |
| [analysis/README.md](analysis/README.md) | 설치, 3+3+1 파일 입력, 보정 저장과 DUT 처리 |
| [balun_eth_rj45](balun_eth_rj45/README.md) | 공통 SMA–RJ45 balun PCB |
| [adapters](adapters/README.md) | JLCPCB용 교체형 어댑터와 지그 검토 |
| [docs/legacy](docs/legacy/README.md) | 종전 SMA 기준 비교 계획; 변경 이력용 |

`balun_slipring/`과 `balun_llc16/`의 커넥터 전용 balun PCB는 기존 설계 자산이다. 현재 기본안은 **공통 RJ45 balun PCB + 커넥터별 수동 어댑터 PCB**이며, 과거 4/8/10장 등 구매 문서는 이 기본안의 최신 발주 수량표가 아니다. 기존 설계·BOM을 삭제하거나 이미 주문한 물량을 취소한 것은 아니다. 기존 `export_jlc_release.ps1`도 새 `adapters/`를 export하지 않는다. [이력 자료 목록](docs/legacy/README.md)에서 적용 범위를 확인한다.

## 결과의 의미

OSL의 모델 오차, 재체결 변화, 지그 간 누설과 mode conversion은 남는다. 소프트웨어의 합성 데이터 검증은 실제 커넥터 정확도 검증과 구분한다. 보정된 IL/RL이 좋아도 산업 환경의 EMC·회전 중 순간단선·장기 수명을 보장하지 않는다. 먼저 실제 길이의 수동 조립체를 평가하고, 이후 동작·환경 시험으로 이어간다.

실측 데이터와 결과는 기본적으로 `measurements/`, `results/`에 두며 Git에서 제외한다. 이 공개 저장소에는 코드와 설계·절차를 관리한다.

## KiCad design adapters/molex_slipring/molex_slipring.kicad_pcb

File adapters/README.md:

# RJ45 공통 지그용 커넥터 어댑터 PCB

설계 의도·이전 전용 지그와의 차이·검토 우선순위는 [설계 검토 인계](../DESIGN_REVIEW_HANDOFF.md)를 따른다. 아래 세 보드는 **수동 연결 어댑터**다. O/S/L/T 표준 PCB와 패널 도면, 제조 release까지 설계된 상태는 아니다.

**선택: 공통 balun 지그는 기존 RJ45 Rev B를 사용하고, 반복 측정용 어댑터는 PCB로 만든다.** 손배선에서 움직이는 untwist·납땜 부위의 형상을 고정할 수 있고, 커넥터 종류가 바뀌어도 balun PCB를 새로 만들 필요가 없다.

상태: **배선 완료, KiCad 10.0.x DRC/ERC/회로도 대조 통과. 실물 mating·패널 기구·JLC 생산 CAM/coupon 승인 전 설계 초안. 공식 계산기 치수 반영은 완료했다.** 정확한 재검증 버전은 `verification.json`에 기록한다. 제조사 임피던스 시험이나 실측 RF 검증까지 완료했다는 뜻은 아니다.

## 구성과 제작 방식

`공통 SMA–balun–RJ45 PCB → 짧은 shielded RJ45 patch cable → 이 어댑터 PCB → DUT`

PCB용 RJ45 jack과 공장제 patch cable을 사용한다. 일반 RJ45 plug를 PCB 끝에 억지로 납땜하는 형태는 피하고, 측정 중 patch cable과 두 PCB를 고정한다. patch cable까지 어댑터 끝 보정에 포함한다. 일반 RJ45 DUT는 어댑터 없이 공통 지그에 연결한다.

| 어댑터 | DUT 쪽 PCB 커넥터 | 조립 판단 |
| --- | --- | --- |
| [m12_slipring](m12_slipring/m12_slipring.kicad_pro) | Finecables `MB12FBAFF08ST-3`, A-code 8핀 **암** | THT; 부품 조달 뒤 손납땜 가능한 구조. PG9 패널/브래킷으로 체결 토크 지지 |
| [m12_llc](m12_llc/m12_llc.kicad_pro) | Finecables `MB12MBAFF08ST-3`, A-code 8핀 **수** | THT; LLC 암 케이블용. 위 암 버전과 핀맵/성별이 다름 |
| [molex_slipring](molex_slipring/molex_slipring.kicad_pro) | Molex `5055680571`, 1.25 mm 5핀 SMT | 손납땜 가능성은 있으나 작은 SMT이므로 stencil/reflow 또는 JLC PCBA 권장 |

M12는 기존 저장소의 PCB 핀형 후보를 사용했다. 사내에 있는 **전선 인출형/납땜 컵형 M12 몸체를 그대로 이 풋프린트에 꽂을 수 있다는 의미가 아니다.** 실제 사내 부품을 재사용하려면 몸체 형식·핀 배열 도면에 맞춘 별도 carrier가 필요하다. 본 세 설계는 표에 적힌 PCB용 부품을 기준으로 한다.

Molex 케이블 housing은 기존 문서의 `5055650501` 후보와 실제 체결을 확인해야 한다. 같은 Molex 브랜드, 같은 핀 수만으로 호환되지 않는다. [제조사 제품 페이지](https://www.molex.com/en-us/products/part-detail/5055680571)의 mating cycle 정격도 고려해 시험용 커넥터의 교체/재체결 기록을 남긴다.

## 고정 핀맵

다음은 **저장소에 있던 사내 케이블 두 종류의 전용 배선**이다. 범용 M12 Ethernet 핀맵이 아니다. 임의 solder jumper 선택지를 넣지 않고 각 PCB 이름과 결선을 고정했다.

| RJ45 | 신호 | M12 슬립링 암 | M12 LLC 수 | Molex 슬립링 |
| --- | --- | ---: | ---: | ---: |
| 1 | A+ | 4 | 8 | 1 |
| 2 | A− | 3 | 2 | 2 |
| 3 | B+ | 2 | 3 | 3 |
| 6 | B− | 1 | 4 | 4 |
| 4, 5, 7, 8 | 미사용 | 연결 안 함 | 연결 안 함 | 연결 안 함 |

- 슬립링 M12 5–8, LLC M12 1/5/6/7, Molex 5는 PCB에서 각각 독립 NC다.
- LLC 전원 핀이나 슬립링 보조 신호/전원 핀을 GND 또는 shell에 연결하지 않는다.
- 핀맵 근거: [슬립링 PINMAP](../balun_slipring/PINMAP.md), [LLC fixture_spec](../balun_llc16/fixture_spec.json). 실제 DUT continuity 검증은 별도다.
- Open/Short/Load는 각 DUT 접속면에서 해당 **pair의 두 핀 사이**로 만든다. 이 어댑터 자체에 O/S/L 스위치를 넣지 않았다. 표준 정의는 [측정 계획](../VNA_TEST_PLAN.md)을 따른다.

## PCB 사양

| 항목 | 설계값 |
| --- | --- |
| 크기 / 홀 | 66 × 40 mm / 네 모서리 Ø3.2 mm NPTH, M3용 |
| stack-up | 4층 `JLC04161H-7628`, 주문 1.6 mm, nominal 1.5862 mm |
| 동박 | 외층 1 oz, 내층 0.5 oz |
| reference planes | L2/L3 SHIELD plane, stitch via 연결; 내층 신호 배선 없음 |
| pair A / pair B | M12 슬립링·Molex는 두 pair 모두 F.Cu; M12 LLC만 각각 F.Cu / B.Cu |
| coupled trunk | 100 Ω 목표, W 0.234 mm / edge gap 0.216 mm |
| KiCad differential pair 설정 | `ETH100`: width 0.234 mm / gap 0.216 mm; `/PAIR_*` 자동 할당 |
| RJ45 pad escape | M12는 W 0.15 mm neckdown; **Molex는 전 구간 W 0.234 mm**. 팬아웃 전체의 100Ω 보장을 의미하지 않음 |
| signal via | 세 어댑터 모두 0개 |
| shield 접속 | RJ45 SH ↔ 내층 plane; TP1은 M12 두 종류에만 있고 Molex에는 DUT-side bond 없음 |
| M12 body | PCB 신호 핀에 shell 접속 없음; 패널/TP1 연결 여부를 별도 정의·기록 |

모든 부품 몸체는 F면이다. LLC M12는 부품 기준 180° 회전이며 도면/PCB의 A-key와 pin 1 표시를 따른다. M12 체결 토크를 신호 핀 납땜부에 맡기지 않는다. M3 head/washer는 OD 7 mm 이하의 기구 검토 범위이며, M12 panel 높이·nut 접근·실제 connector seating은 실물 도면으로 맞춘다.

| 어댑터 | A+ / A− 배선 길이 | B+ / B− 배선 길이 |
| --- | ---: | ---: |
| M12 슬립링 | 32.793 / 31.855 mm | 32.253 / 33.084 mm |
| M12 LLC | 36.659 / 36.659 mm | 28.514 / 28.514 mm |
| Molex 슬립링 | 31.247 / 30.455 mm | 30.410 / 29.424 mm |

M12 슬립링은 M12 body를 −30° 회전하고 두 pair를 F.Cu에 배치했다. PCB track 길이 차이는 A 약 0.94 mm, B 약 0.83 mm이며 signal via는 없다. [계산·검증 상세](../docs/jlcpcb/IMPEDANCE.md)를 참고한다.

길이는 track 중심선 합계이며 커넥터 내부 핀 길이와 via 전기 길이를 포함하지 않는다. M12 슬립링과 Molex는 큰 길이보정 우회로·layer change보다 짧고 밀접한 배선을 우선했다. Molex는 후속 RJ45 탈출부 개선으로 0.15 mm 구간을 제거했고, PCB track 길이 차이는 **A 0.792 mm / B 0.987 mm**다. 긴 결합 구간과 페어 간격을 함께 고려했으며 [수정 의도·전후 비교](../docs/molex-routing/README.md)를 참고한다. 최종 mode conversion이나 정확한 임피던스는 이 표만으로 보장하지 않는다.

**RF 재검토 우선 항목:** 특히 M12 LLC pair A의 넓은 fanout이 작은 skew를 허용한 더 짧고 밀접한 배선보다 유리한지 확인해야 한다. track 합계 길이 일치에 앞서 uncoupled 길이, loop 면적, 기준면에 대한 대칭을 함께 비교한다. 현재 형상의 우월성을 EM 해석이나 실측으로 검증하지 않았다.

## 레이아웃

빨강 F.Cu, 파랑 B.Cu. M12 LLC의 교차처럼 보이는 다른 색 선은 서로 다른 외층이며 사이에 두 reference plane이 있다. M12 슬립링과 Molex의 두 pair는 모두 빨강 F.Cu다. `planes.svg`에서 채워진 내층 plane도 확인할 수 있다.

### M12 슬립링용 암

[회로도](m12_slipring/m12_slipring.kicad_sch) · [PCB](m12_slipring/m12_slipring.kicad_pcb) · [내층](m12_slipring/planes.svg)

### M12 LLC용 수

[회로도](m12_llc/m12_llc.kicad_sch) · [PCB](m12_llc/m12_llc.kicad_pcb) · [내층](m12_llc/planes.svg)

### Molex 슬립링용

[회로도](molex_slipring/molex_slipring.kicad_sch) · [PCB](molex_slipring/molex_slipring.kicad_pcb) · [내층](molex_slipring/planes.svg)

## 검증과 JLC 제작

- [기존 지그 검토](FIXTURE_REVIEW.md)
- [JLCPCB 제작 조건과 조립 BOM](JLCPCB_BUILD.md)
- [검증 결과와 CAD SHA-256](verification.json)
- [풋프린트 출처](FOOTPRINT_SOURCES.md)

```bash
# KiCad 10의 pcbnew가 설치된 Python으로 새 폴더에만 재생성
python adapters/generate_adapters.py /path/to/new-output
# 저장소의 세 보드 zone refill / DRC / ERC / parity / pinmap / SVG
python adapters/verify_adapters.py --kicad-cli /path/to/kicad-cli
```

generator는 이미 존재하는 출력 폴더를 덮어쓰지 않는다. `verify_adapters.py`는 zone fill을 보드에 저장한 뒤 검사와 hash를 기록한다. 검사 통과는 핀맵의 CAD 전사·배선 검증이며 제조사 mating 검증이나 양산 release 승인이 아니다.

세 프로젝트의 `ETH100` netclass에는 differential width 0.234 mm와 gap 0.216 mm가 실제 저장되어 있다. 사용자 규칙은 coupled gap 최소 0.21 mm, pair skew 최대 2.00 mm, uncoupled 길이 최대 16.60 mm와 signal via 0개를 DRC에서 추가로 강제한다.

Parts:
J1: RJ45 RJE591885401; RJ45_Amphenol_RJE59-188-5401
J2: 5055680571; Molex_5055680571

Connections:
/PAIR_A_N: J1.2, J2.2
/PAIR_A_P: J1.1, J2.1
/PAIR_B_N: J1.6, J2.4
/PAIR_B_P: J1.3, J2.3
/SHIELD: J1.SH

Notes on the sheet:
MOLEX 5P / SLIPRING; PIN 5 NC; VERIFY HOUSING
Passive two-pair adapter; no magnetics, no PoE, no active Ethernet.
100 ohm pair trunks; JLC04161H-7628; 4 layers; 1.6 mm nominal.
Inner SHIELD planes connect to RJ45 shield; no DUT-side shield bond.
Molex housing and actual mating/pin numbering require sample verification.
Calibration reference plane: DUT connector mating plane after this adapter.

Board: 4 copper layers, 66.0 x 40.0 mm, 6 parts (0 on the bottom side), 4 nets.

Other parts of the board:
H1, H2, H3, H4: (no value)

## KiCad design adapters/m12_slipring/m12_slipring.kicad_pcb

Parts:
J1: RJ45 RJE591885401; RJ45_Amphenol_RJE59-188-5401
J2: MB12FBAFF08ST-3; Finecables_MB12FBAFF08ST-3
TP1: Shield_SolderPoint

Connections:
/PAIR_A_N: J1.2, J2.3
/PAIR_A_P: J1.1, J2.4
/PAIR_B_N: J1.6, J2.1
/PAIR_B_P: J1.3, J2.2
/SHIELD: J1.SH, TP1.1

Notes on the sheet:
M12 FEMALE / SLIPRING; 5-8 NC; VERIFY MATE
Passive two-pair adapter; no magnetics, no PoE, no active Ethernet.
100 ohm pair trunks; JLC04161H-7628; 4 layers; 1.6 mm nominal.
Inner SHIELD planes connect to RJ45 shield. M12 body bond is mechanical/external.
M12 mounting bracket and actual mating/pin numbering require sample verification.
Calibration reference plane: DUT connector mating plane after this adapter.

Board: 4 copper layers, 66.0 x 40.0 mm, 7 parts (0 on the bottom side), 5 nets.

Other parts of the board:
H1, H2, H3, H4: (no value)

## KiCad design balun_eth_rj45/balun_eth_rj45.kicad_pcb

File balun_eth_rj45/README.md:

# balun_eth_rj45 Rev B

**2026-09-05 현재 역할:** 교체형 수동 어댑터와 공유하는 공통 balun PCB다. 방향 전환 당시 회로/동박을 유지했으며, 후속 임피던스 확인에서 배선 폭을 수정했다. [2026-09-05 계산·검증](../docs/jlcpcb/IMPEDANCE.md)과 [주문 화면 가이드](../docs/jlcpcb/README.md)를 따른다. 설계 선택 이유와 검증 한계는 [설계 검토 인계](../DESIGN_REVIEW_HANDOFF.md), 실제 CAD 검토는 [FIXTURE_REVIEW](../adapters/FIXTURE_REVIEW.md)를 참고한다.

2026-09-03: 기존 회로도를 채널별 A3 한 장으로 재배치했다. 연결·부품·DNP와 PCB는 그대로이며, [가독성 정리 결과 및 PDF](../SCHEMATIC_READABILITY_2026-09-03.md)를 참고한다.

LibreVNA 2-port로 일반 Ethernet 케이블과 전용 Ethernet 슬립링을 측정하기 위한 수동 4-pair RJ45 지그다. 동일 보드 2장을 DUT 양쪽에 사용하며, 한 번에 한 pair를 VNA의 두 포트로 측정한다. through 측정에서는 각 보드의 미사용 SMA 3개씩, 두 장 합계 **6개**에 외부 50 Ω 종단기를 연결한다. NEXT/FEXT 등 다른 포트 배치에서도 전체 8개 중 미사용 6개를 종단한다.

> 수동 DUT 전용이다. PoE나 동작 중인 Ethernet 장비에는 연결하지 않는다.

현재 기본안은 이 공통 PCB 두 장과 교체형 RJ45–M12/Molex 어댑터다. 최종 기준면은 어댑터 뒤 DUT 접속면으로 두며 [공통 측정 계획](../VNA_TEST_PLAN.md)과 [어댑터 설계](../adapters/README.md)를 따른다. 기존 LLC/M12 전용 balun PCB와 PCBA 10장 계획은 이전 설계 선택지로 보존한다.

## 채널 구성

| SMA | RJ45 pair | Balun |
|---|---|---|
| J2 / A | 1(+)–2(-) | T1 |
| J3 / B | 3(+)–6(-) | T2 |
| J4 / C | 4(+)–5(-) | T3 |
| J5 / D | 7(+)–8(-) | T4 |

T1–T4는 Mini-Circuits `ADT2-1T+`다. primary pin 3은 SMA center, pin 1은 GND이며, secondary pin 4/6은 각각 pair P/N, pin 5는 RCT, pin 2는 NC다.

ADT2-1T+의 dot은 primary pin 3과 secondary pin 6이다. 따라서 현재 `P=pin 4`, `N=pin 6` 명명은 **지그 한 장에서 한 번의 극성 반전**을 만든다. 동일한 두 보드를 back-to-back으로 쓰는 기본 비교에서는 두 번 반전되어 전달 극성이 복구되지만, 단일 지그 de-embedding, 절대 위상 또는 mixed-mode 부호에는 이 convention을 반영해야 한다.

## JLCPCB Rev B 기판 사양

- KiCad 10, 4층, 주문 두께 1.6 mm, 외층 1 oz / 내층 0.5 oz.
- JLCPCB stack-up `JLC04161H-7628 (Standard)`, nominal stack 1.5862 mm.
- 재료 `FR-4 TG155 / Nan Ya NP-155F`, green solder mask, ENIG.
- L1(F.Cu): 신호와 필요한 짧은 GND 연결만 사용. blanket GND pour 없음.
- L2(In1.Cu): 끊김 없는 `/GND` plane.
- L3(In2.Cu): 끊김 없는 `/GND` plane.
- L4(B.Cu): pair B와 필요한 짧은 GND 연결만 사용. blanket GND pour 없음.
- L1/L4 신호 아래의 기준면은 각각 L2/L3이며, outer pour가 없는 non-coplanar microstrip으로 계산했다.

상세 주문값과 적층 구조는 [JLCPCB_FAB_NOTES.md](JLCPCB_FAB_NOTES.md)를 따른다. 주문 화면에서 다른 stack-up으로 자동 변경되면 그대로 발주하지 말고 선폭을 다시 계산한다.

## 임피던스와 배선 규칙

- SMA single-ended 50 Ω 목표: 외층 폭 `0.357 mm`.
- Ethernet differential 100 Ω 목표: 외층 폭 `0.234 mm`, edge-to-edge gap `0.216 mm`. 2026-09-05 공식 계산기 결과를 반영한 nominal 치수이며 제조 CAM/coupon은 별도 확인한다.
- RJ45 pin field만 폭 `0.15 mm`로 짧게 neck-down한다.
- J1 signal PTH는 pad `1.30 mm`, drill `0.90 mm`; 인접 PTH와 escape trace 사이 최소 동박 간격은 약 `0.295 mm`다.
- 일반 신호 via는 `0.60/0.30 mm`; pair B만 P/N에 각각 같은 through-via 1개를 쓴다.
- A/C/D는 F.Cu, B는 J1 쪽 B.Cu에서 진행한 뒤 T2 앞에서 대칭적으로 F.Cu로 전환한다.
- T2의 기준면 전환용 GND via 네 개는 P/N 사이가 아닌 바깥쪽에 대칭 배치한다. 각 signal via와의 중심 간격은 `1.355 mm`, 동박 가장자리 간격은 `0.755 mm`다.
- T4도 F.Cu에 둔다. B.Cu로 뒤집으면 F.Cu 전용 SMA center launch 때문에 single-ended 쪽 via가 필요하고 채널 간 fixture 대칭성이 나빠진다.
- SMA는 MyAntenna `A-SMA-KE-16.5A` (`C22467617`)로 통일한다. 권장 PCB 두께 `1.6 ±0.05 mm`에 nominal 1.5862 mm는 들어가지만 JLC 일반 두께 ±10%는 이 기구 공차를 보장하지 않으며, 정격은 50 Ω / DC–6 GHz다. 기존 Amphenol `132289`는 PCB 두께 상한 1.57 mm가 nominal stack보다 작아 최종 BOM에서 제외했다.
- `A-SMA-KE-16.5A`는 기존 JLC 조달 검토에서 Standard PCBA의 wave-solder/high-difficulty 품목으로 분류됐다. 현재 CAD의 부품/land pattern을 유지하며, 실제 조립 방식에 맞춰 board-edge 안착, 방향, 납땜 접근성과 두께 공차를 확인한다. PCBA를 선택하면 업체 공정도 확인한다.
- 서로 다른 controlled signal 사이 최소 clearance는 `0.60 mm`; 가능하면 그 이상을 유지한다.
- 결합 gap은 최소 `0.21 mm` / 권장 `0.216 mm`; fan-out을 포함한 uncoupled 길이는 일반 pair `16.0 mm`, split pair B `16.5 mm` 이하로 제한한다.
- transformer 앞에서는 한쪽 선에 짧은 U자 보정을 넣지 않는다. 대신 coupled trunk의 마지막 분기점을 약 1.3 mm 이동해 부드러운 fan-out 형상으로 end-to-end 길이를 맞춘다.
- RCT4를 포함한 선택형 CT-GND 경로는 0 Ω 저항의 GND pad를 내부 GND plane에 짧게 연결한다. RCT가 DNP이면 GND측 동박과 via는 plane에 남지만 transformer center-tap으로 이어지는 경로는 개방된다.
- L2/L3에는 track 및 non-GND zone을 금지한다.

저장된 외층 선분 길이 검산 결과는 다음과 같다. B만 P/N에 동일한 via 한 개가 있으므로 via 지연도 대칭이다.

| Pair | P length | N length | P–N 차이 | P/N via |
|---|---:|---:|---:|---:|
| A | 44.9649 mm | 44.9649 mm | 0.0000 mm | 0 / 0 |
| B | 32.9301 mm | 32.9301 mm | 0.0000 mm | 1 / 1 |
| C | 32.8357 mm | 32.8357 mm | 0.0000 mm | 0 / 0 |
| D | 43.6677 mm | 43.6677 mm | 0.0000 mm | 0 / 0 |

KiCad의 `skew (within_diff_pairs)`는 전체 선분 합이 아니라 결합 구간을 평가한다. bend의 안쪽/바깥쪽 차이를 허용하도록 최대 `0.55 mm`로 두었고, 위 표의 end-to-end 합계는 별도로 검산했다.

## 조립

- T1–T4: Mini-Circuits `ADT2-1T+`, CD542.
- J1: Amphenol `RJE591885401`, CAT6 shielded, LED/magnetics 없음.
- J2–J5: MyAntenna `A-SMA-KE-16.5A` edge-mount SMA, JLC/LCSC `C22467617`; 현재 CAD 기준 부품. 손납땜/PCBA 중 실제 조립 방법에 맞는 안착·납땜 조건을 확인한다.
- RCT1–RCT4: 각 보드에서 기본 DNP이며, 이 `CT-FLOAT` 상태를 golden/DUT 비교의 baseline으로 사용한다.
- `CT-GND` 영향만 별도로 비교할 때 두 보드의 RCT1–RCT4, 총 8개 위치에 0 Ω을 모두 장착한다. 보드 한쪽만 또는 일부 pair만 장착한 mixed 상태는 사용하지 않는다.
- RSH1: 동일 PCB 두 장 중 VNA Port 1 쪽 보드에만 기본 0 Ω을 장착하고, Port 2 쪽 보드는 DNP로 둬 DUT shield의 DC 접점을 한 점으로 만든다. 어느 쪽을 접지했는지는 결과와 함께 기록한다.
- CSH1: 두 보드 모두 기본 DNP. AC shield bond 시험 시 해당 보드의 RSH1을 제거한 뒤 1 nF / 2 kV를 장착한다. 한 보드에서 RSH1과 CSH1을 동시에 장착하지 않는다.

LibreVNA의 두 RF port는 공통 GND를 사용하므로 RCT 8개를 장착하면 두 fixture의 center tap에 공통모드 기준 경로가 추가된다. 따라서 `CT-GND` 결과는 케이블/슬립링 고유값이 아니라 해당 종단 조건을 포함한 비교값으로 해석한다.

두 지그는 같은 PCB artwork를 사용하지만 기본 RSH1 상태는 서로 다르다. CT-FLOAT와 CT-GND를 비교할 때 RSH1/CSH1과 cable 배치를 고정하고, **CT 상태 변경 후 커넥터 끝 O/S/L/T 보정을 다시 취득**한다. patch shield, 어댑터 SHIELD plane, M12 body/패널에 추가 접지 경로가 있으면 한쪽 RSH1만 장착했다는 사실만으로 전체가 단일 접지점이라고 할 수 없다. 실제 경계를 기록한다.

현재 구성의 최소 공통 지그는 한 측정 세트당 **2장**이며, 예비품과 동시 운용 세트 수를 포함한 신규 총 발주량은 아직 정하지 않았다. 사용자가 희망한 bare PCB + 손납땜을 기본 조립 선택지로 검토하고, 작은 RF/SMT 부품의 작업성에 따라 부분 reflow/PCBA를 선택할 수 있다. 과거 문서의 “사용자 납땜을 가정하지 않는다”는 조건을 현재 요구에 적용하지 않는다.

RSH1 조립 상태는 실제 작업 지시와 보드 표기에 반영한다. 공통 CAD/export의 RSH1 DNP 후보를 그대로 쓰면 bonded variant가 자동으로 만들어지지 않는다. 과거 구매 수량·BOM은 [이력 자료](../docs/legacy/README.md)이며, 새 어댑터의 조립 부품은 [JLCPCB_BUILD](../adapters/JLCPCB_BUILD.md)에 있다. 조립 후 RJ45 1–8, shield tab, SMA–transformer 연결과 RSH1 상태를 continuity로 확인한다.

## 측정 순서

1. 두 coax 끝에서 50 Ω full 2-port SOLT를 수행하고 활성화한다.
2. 이 보드와 선택한 어댑터·RJ45 연결을 고정한다. 각 보드의 미사용 SMA를 50 Ω으로 종단한다.
3. 어댑터 뒤 DUT 접속면에서 Port 1 O/S/L 3개, Port 2 O/S/L 3개, reciprocal 자작 thru 1개를 측정해 저장한다.
4. [Python 도구](../analysis/README.md)로 커넥터 끝 UnknownThru 보정계수를 만든다.
5. 같은 SMA 보정 상태에서 DUT를 측정하고 저장된 계수로 보정한 100 Ω 결과를 분석한다.
6. pair·어댑터·포트 할당·CT/shield 상태가 달라지면 해당 구성의 보정을 새로 만든다.

SMA SOLT만 적용한 원본에는 지그가 포함된다. Python 결과는 표준 모델과 고정된 두 error box 가정 아래 커넥터 기준면으로 이동한 balanced effective two-port다. full mixed-mode Sdd/Sdc/Scd/Scc나 산업 환경 적합 판정을 뜻하지 않는다. NEXT/FEXT는 별도 연결별 보정 및 fixture 누설 검증이 필요하다. 최신 설정과 결과 해석은 [VNA_TEST_PLAN.md](../VNA_TEST_PLAN.md)를 따른다.

## 파일과 재생성 주의

- `balun_eth_rj45.kicad_pcb/.kicad_pro/.kicad_dru`: Rev B 설계와 규칙.
- `balun_eth_rj45_drc.rpt`: 최종 KiCad DRC 결과.
- `apply_jlc_rev_b.py`: 수동 저장본을 JLC Rev B로 변환한 재현용 updater. 전체/`--routing-only` 경로 모두 변경 뒤 native KiCad zone refill+save와 DRC/schematic parity를 강제하고, 실패하면 nonzero로 중단한다. 이미 Rev B인 보드에는 전체 변환을 다시 실행하지 말고 fan-out만 갱신할 때 `--routing-only`를 사용한다.
- `generate_pcb.py`: 이전 Rev A 생성기. 기본 실행은 차단되어 있으며 현 Rev B PCB를 만들지 못한다.
- `fabrication/`과 `*_fabrication_HOLD.zip`: 폐기된 Rev A 로컬 참고 자료다. Git에서 제외하며 발주에 사용하지 않는다.

제작 Gerber는 항상 zone을 확인·재충전하는 `--check-zones`로 export하고, In1/In2에 실제 GND plane region이 있는지 CAM에서 확인한다. updater가 fill을 저장하더라도 이후 수동 편집본에 대한 release 검사는 생략하지 않는다.

## 공식 자료

- [JLCPCB impedance calculator guide](https://jlcpcb.com/help/article/user-guide-to-the-jlcpcb-impedance-calculator)
- [JLCPCB impedance stack-ups](https://jlcpcb.com/impedance)
- [JLCPCB multilayer structures](https://jlcpcb.com/help/article/multi-layer-pcb-standard-laminated-structures)
- [JLCPCB PCB capabilities](https://jlcpcb.com/capabilities/pcb-capabilities/)
- [ADT2-1T+ datasheet](https://www.minicircuits.com/pdfs/ADT2-1T+.pdf)
- [RJE591885401 product page](https://www.amphenol-cs.com/product/rje591885401.html)
- [MyAntenna A-SMA-KE-16.5A / C22467617](https://jlcpcb.com/partdetail/MyAntenna-A_SMA_KE_165A/C22467617)
- 현재 제작 범위는 [설계 검토 인계](../DESIGN_REVIEW_HANDOFF.md)와 [어댑터 제작 초안](../adapters/JLCPCB_BUILD.md)을 따른다. 루트의 기존 합산 구매 CSV/가이드는 과거 구성의 기록이다.

Parts:
CSH1: 1nF 2kV DNP; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; not fitted
J1: RJE591885401 CAT6 NO-MAGNETICS; RJ45_Amphenol_RJE59-188-5401; MPN RJE591885401; LCSC Part # C5386678
J2: SMA_A; SMA_MyAntenna_A-SMA-KE-16.5A_EdgeMount; MPN A-SMA-KE-16.5A; LCSC Part # C22467617
J3: SMA_B; SMA_MyAntenna_A-SMA-KE-16.5A_EdgeMount; MPN A-SMA-KE-16.5A; LCSC Part # C22467617
J4: SMA_C; SMA_MyAntenna_A-SMA-KE-16.5A_EdgeMount; MPN A-SMA-KE-16.5A; LCSC Part # C22467617
J5: SMA_D; SMA_MyAntenna_A-SMA-KE-16.5A_EdgeMount; MPN A-SMA-KE-16.5A; LCSC Part # C22467617
RCT1, RCT2, RCT3, RCT4: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN 0805W8F0000T5E; LCSC Part # C17477; not fitted
RSH1: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MPN 0805W8F0000T5E; LCSC Part # C17477; not fitted
T1, T2, T3, T4: ADT2-1T+; Mini-Circuits_CD542_H2.84mm; MPN ADT2-1T+; LCSC Part # C5223988
TP1: GND_RF; TestPoint_Loop_D2.50mm_Drill1.0mm; MPN 5001; LCSC Part # C238122
TP2: RJ45_SHIELD; TestPoint_Loop_D2.50mm_Drill1.0mm; MPN 5001; LCSC Part # C238122

Connections:
/DA_N: J1.2, T1.6
/DA_P: J1.1, T1.4
/DB_N: J1.6, T2.6
/DB_P: J1.3, T2.4
/DC_N: J1.5, T3.6
/DC_P: J1.4, T3.4
/DD_N: J1.8, T4.6
/DD_P: J1.7, T4.4
/GND: CSH1.1, J2.2 (Ext), J3.2 (Ext), J4.2 (Ext), J5.2 (Ext), RCT1.1, RCT2.1, RCT3.1, RCT4.1, RSH1.1, T1.1, T2.1, T3.1, T4.1, TP1.1
/SHIELD: CSH1.2, J1.SH, RSH1.2, TP2.1
unnamed: J2.1 (In), T1.3
unnamed: J3.1 (In), T2.3
unnamed: J4.1 (In), T3.3
unnamed: J5.1 (In), T4.3
unnamed: RCT1.2, T1.5
unnamed: RCT2.2, T2.5
unnamed: RCT3.2, T3.5
unnamed: RCT4.2, T4.5

Notes on the sheet:
RJ45 / FOUR-PAIR VNA FIXTURE
RJ45 이더넷 케이블 측정 지그 | 4-channel VNA fixture
A / RJ45 1(+) - 2(-)
50 ohm
DNP / CT FLOAT
1:2 impedance
B / RJ45 3(+) - 6(-)
C / RJ45 4(+) - 5(-)
D / RJ45 7(+) - 8(-)
RJ45 / NO MAGNETICS
Component pin numbers, not a mating-face drawing.
SHIELD OPTIONS / TEST POINTS
DNP IN COMMON CAD
OPTIONAL AC BOND / DNP
PCBA: SHIELD-BONDED / SHIELD-FLOAT variants.
Supplier fits RSH1 only on the BONDED boards.
ASSEMBLY / MEASUREMENT NOTES
1. Passive DUT only. Disconnect PoE and all active Ethernet equipment before connecting the VNA.
2. Two identical PCB artworks; measure one path at a time and terminate all six unused SMA ports with 50 ohm loads.
3. RCT1..RCT4 are DNP on this board. The default comparison condition is CT-FLOAT on both endpoint boards.
4. CT-GND is a separate controlled comparison: fit all eight RCTs across two boards; do not mix CT states.
5. This common CAD keeps RSH1 and CSH1 DNP. Final PCBA variants follow PCBA_PURCHASE_SCOPE_2026-09-03.md.
6. RSH1 fitted = direct shield bond; CSH1 alone = optional AC bond; both DNP = floating. Never fit both together.
7. Final shield variants are assembled by the supplier; legacy hand-fit property text is not a user soldering instruction.
8. Coax O/S/L + THRU calibration leaves the PCB / balun response embedded. Keep REF/DUT fixture conditions fixed.
9. Secondary convention P=pin 4, N=pin 6 is unchanged. Account for single-fixture polarity in phase/de-embedding work.
10. No TVS, common-mode choke, MagJack, series capacitors or on-board 50 ohm loads are added to the signal paths.

Board: 4 copper layers, 80.0 x 74.0 mm, 21 parts (3 on the bottom side), 18 nets.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3

File balun_eth_rj45/balun_eth_rj45_bom.csv:

"Reference","Value","Footprint","Manufacturer","MPN","JLCPCB/LCSC Part #","Assembly","QUANTITY","DNP","Procurement","Stock snapshot (2026-08-13 22:45 KST)","Notes"
"CSH1","1nF 2kV DNP","Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder","","","","DNP; fit only as a separately qualified shield experiment after removing RSH1","1","DNP","DNP_NO_BUY","not selected","No capacitor is included in the baseline order"
"J1","RJE591885401 CAT6 NO-MAGNETICS","balun_eth_rj45:RJ45_Amphenol_RJE59-188-5401","Amphenol Communications Solutions","RJE591885401","C5386678","FIT by JLC THT wave solder","1","","ORDERABLE","JLC 11","Recheck stock and orientation in each design-specific PCBA job"
"J2","SMA_A","balun_eth_rj45:SMA_MyAntenna_A-SMA-KE-16.5A_EdgeMount","MyAntenna","A-SMA-KE-16.5A","C22467617","FIT by JLC Standard PCBA wave solder after placement/fixture review","1","","ORDERABLE_WITH_PCBA_REVIEW","JLC 491","1.6 mm recommended board thickness; high assembly difficulty; verify land pattern, edge seating and orientation without substitution"
"J3","SMA_B","balun_eth_rj45:SMA_MyAntenna_A-SMA-KE-16.5A_EdgeMount","MyAntenna","A-SMA-KE-16.5A","C22467617","FIT by JLC Standard PCBA wave solder after placement/fixture review","1","","ORDERABLE_WITH_PCBA_REVIEW","JLC 491","1.6 mm recommended board thickness; high assembly difficulty; verify land pattern, edge seating and orientation without substitution"
"J4","SMA_C","balun_eth_rj45:SMA_MyAntenna_A-SMA-KE-16.5A_EdgeMount","MyAntenna","A-SMA-KE-16.5A","C22467617","FIT by JLC Standard PCBA wave solder after placement/fixture review","1","","ORDERABLE_WITH_PCBA_REVIEW","JLC 491","1.6 mm recommended board thickness; high assembly difficulty; verify land pattern, edge seating and orientation without substitution"
"J5","SMA_D","balun_eth_rj45:SMA_MyAntenna_A-SMA-KE-16.5A_EdgeMount","MyAntenna","A-SMA-KE-16.5A","C22467617","FIT by JLC Standard PCBA wave solder after placement/fixture review","1","","ORDERABLE_WITH_PCBA_REVIEW","JLC 491","1.6 mm recommended board thickness; high assembly difficulty; verify land pattern, edge seating and orientation without substitution"
"RCT1-RCT4","0R","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","UNI-ROYAL","0805W8F0000T5E","C17477","DNP DEFAULT; fit all eight across both fixture boards only for a labelled CT-GND comparison","4","DNP","DNP_NO_BUY","JLC 7971216","Use the loose 0 ohm pack only if CT-GND is intentionally tested; never mix ends or pairs"
"RSH1","0R","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","UNI-ROYAL","0805W8F0000T5E","C17477","DNP in both PCBA jobs; hand-fit on the labelled Port-1 fixture only after receipt","1","DNP","ORDERABLE_MANUAL","JLC 7971216","Identical artwork cannot express the two assembly variants in one common JLC job"
"T1-T4","ADT2-1T+","RF_Mini-Circuits:Mini-Circuits_CD542_H2.84mm","Mini-Circuits","ADT2-1T+","C5223988","FIT by JLC SMT","4","","ORDERABLE","JLC 159","Extended part; no turns-ratio or footprint substitution"
"TP1","GND_RF","TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm","Keystone Electronics","5001","C238122","FIT by JLC THT wave solder","1","","ORDERABLE_WITH_HOLE_REVIEW","JLC 3043","Vendor nominal hole is 1.02 mm versus local 1.00 mm drill; confirm finished-hole tolerance/retention or trial-fit before assembly approval"
"TP2","RJ45_SHIELD","TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm","Keystone Electronics","5001","C238122","FIT by JLC THT wave solder","1","","ORDERABLE_WITH_HOLE_REVIEW","JLC 3043","Vendor nominal hole is 1.02 mm versus local 1.00 mm drill; confirm finished-hole tolerance/retention or trial-fit before assembly approval"

## Code that names these connections

File balun_slipring/readable_schematic.py (part):

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                  heading=f"{letter} / RJ45 {pair[0]}(+) - {pair[1]}(-)", heading_y=y - 26.67)
    s.text("connector-heading", "RJ45 / NO MAGNETICS", 355.6, 39.37, 1.6, bold=True)
    s.place("J1", 337.82, 69.85, (337.82, 46.99), (355.6, 104.14), size=1.15)
    pins = {1: "DA_P", 2: "DA_N", 3: "DB_P", 4: "DC_P", 5: "DC_N", 6: "DB_N", 7: "DD_P", 8: "DD_N"}
    for pin, net in pins.items():
        y = 77.47 - (pin - 1) * 2.54
        s.wire(f"J1:{pin}:wire", 347.98, y, 368.3, y)
        s.label(f"J1:{pin}:label", net, 368.3, y)
    s.wire("J1:shield-wire", 337.82, 82.55, 337.82, 92.71)
    s.label("J1:shield-label", "SHIELD", 337.82, 92.71)
    s.text("connector-note", "Component pin numbers, not a mating-face drawing.", 355.6, 112.395, 1.0)
    s.text("shield-heading", "SHIELD OPTIONS / TEST POINTS", 355.6, 129.54, 1.45, bold=True)
    for ref, y in (("RSH1", 151.13), ("CSH1", 176.53)):
        s.place(ref, 355.6, y, (355.6, y - 10.16), (355.6, y - 6.35), rotation=270)
        s.wire(f"{ref}:shield-wire", 330.2, y, 351.79, y)
        s.label(f"{ref}:shield-label", "SHIELD", 330.2, y)
        s.wire(f"{ref}:ground-wire", 359.41, y, 381, y)
        s.label(f"{ref}:ground-label", "GND", 381, y)
        s.text(f"{ref}:dnp", "DNP IN COMMON CAD" if ref == "RSH1" else "OPTIONAL AC BOND / DNP", 355.6, y + 7.62, 1.1)
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